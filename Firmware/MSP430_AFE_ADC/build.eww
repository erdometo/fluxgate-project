<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\msp430afe-test\test.ewp</path>
    </project>
    <batchBuild />
</workspace>
